FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://uio_pdrv_genirq_make_name_controllable.patch"